options:
  parameters:
    author: labcom
    generate_options: qt_gui
    id: pruebaMod
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: D1
  id: variable_qtgui_range
  parameters:
    label: Delay 1
    rangeType: int
    start: '0'
    step: '1'
    stop: '100'
    value: '50'
  states: {}
- name: D2
  id: variable_qtgui_range
  parameters:
    label: Delay 2
    rangeType: int
    start: '0'
    step: '1'
    stop: '100'
    value: '50'
  states: {}
- name: D3
  id: variable_qtgui_range
  parameters:
    label: Delay 3
    rangeType: int
    start: '0'
    step: '1'
    stop: '100'
    value: '50'
  states: {}
- name: fs
  id: variable
  parameters:
    value: '1000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 100*fs
  states: {}
- name: w
  id: variable_qtgui_range
  parameters:
    label: Ancho de Pulso
    rangeType: int
    start: '0'
    step: '1'
    stop: '100'
    value: '50'
  states: {}
- name: ModuladorPAM_0
  id: ModuladorPAM
  parameters:
    d: w
    fs: fs
    samp_rate: samp_rate
  states: {}
- name: ModuladorPAM_0_0
  id: ModuladorPAM
  parameters:
    d: w
    fs: fs
    samp_rate: samp_rate
  states: {}
- name: ModuladorPAM_0_1
  id: ModuladorPAM
  parameters:
    d: w
    fs: fs
    samp_rate: samp_rate
  states: {}
- name: ModuladorPAM_0_1_0
  id: ModuladorPAM
  parameters:
    d: w
    fs: fs
    samp_rate: samp_rate
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '100'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: fs
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SQR_WAVE
  states: {}
- name: analog_sig_source_x_0_1
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '100'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SQR_WAVE
  states: {}
- name: analog_sig_source_x_0_2
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '100'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_TRI_WAVE
  states: {}
- name: analog_sig_source_x_0_2_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '100'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SAW_WAVE
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    num_inputs: '4'
    type: float
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: 50-w
    type: float
  states: {}
- name: blocks_delay_0_0
  id: blocks_delay
  parameters:
    delay: D1
    type: float
  states: {}
- name: blocks_delay_0_1
  id: blocks_delay
  parameters:
    delay: D2
    type: float
  states: {}
- name: blocks_delay_0_2
  id: blocks_delay
  parameters:
    delay: D3
    type: float
  states: {}
- name: blocks_multiply_xx_1
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: 1024*8
    nconnections: '5'
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    nconnections: '5'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: float
  states: {}

connections:
- [ModuladorPAM_0, '0', blocks_add_xx_0, '0']
- [ModuladorPAM_0, '0', qtgui_freq_sink_x_0, '0']
- [ModuladorPAM_0, '0', qtgui_time_sink_x_0, '0']
- [ModuladorPAM_0_0, '0', blocks_delay_0_0, '0']
- [ModuladorPAM_0_1, '0', blocks_delay_0_1, '0']
- [ModuladorPAM_0_1_0, '0', blocks_delay_0_2, '0']
- [analog_sig_source_x_0, '0', ModuladorPAM_0, '0']
- [analog_sig_source_x_0_0, '0', blocks_delay_0, '0']
- [analog_sig_source_x_0_0, '0', blocks_multiply_xx_1, '0']
- [analog_sig_source_x_0_1, '0', ModuladorPAM_0_0, '0']
- [analog_sig_source_x_0_2, '0', ModuladorPAM_0_1, '0']
- [analog_sig_source_x_0_2_0, '0', ModuladorPAM_0_1_0, '0']
- [blocks_add_xx_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_delay_0, '0', blocks_multiply_xx_1, '1']
- [blocks_delay_0_0, '0', blocks_add_xx_0, '1']
- [blocks_delay_0_0, '0', qtgui_freq_sink_x_0, '1']
- [blocks_delay_0_0, '0', qtgui_time_sink_x_0, '1']
- [blocks_delay_0_1, '0', blocks_add_xx_0, '2']
- [blocks_delay_0_1, '0', qtgui_freq_sink_x_0, '2']
- [blocks_delay_0_1, '0', qtgui_time_sink_x_0, '2']
- [blocks_delay_0_2, '0', blocks_add_xx_0, '3']
- [blocks_delay_0_2, '0', qtgui_freq_sink_x_0, '3']
- [blocks_delay_0_2, '0', qtgui_time_sink_x_0, '3']
- [blocks_multiply_xx_1, '0', qtgui_freq_sink_x_0, '4']
- [blocks_multiply_xx_1, '0', qtgui_time_sink_x_0, '4']

metadata:
  file_format: 1
